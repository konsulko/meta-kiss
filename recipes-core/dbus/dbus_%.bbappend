FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"

PACKAGECONFIG_append := " user-session"
